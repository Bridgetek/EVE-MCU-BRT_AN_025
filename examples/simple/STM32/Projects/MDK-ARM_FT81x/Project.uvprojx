# Keil uVision project Project.uvprojx, settings and files
target STM32F0308-Discovery (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0308-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER,USE_STM320308_DISCO,PLATFORM_STM32
  c misc: --C99
  c include: ..\system\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F0308-Discovery;..\..\Drivers\BSP\Components\Common;..\..\Utilities\Log;..\..\Utilities\CPU;..\lib\eve\include;..\;..\main\;..\example\;..\..\..\common\;..\..\..\..\..\include\;..\..\..\..\..\source\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/User
    ../system/Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c
    ../main/: main.c main.h
    ../../../common/: eve_calibrate.c eve_example.c eve_fonts.c eve_helper.c eve_images.c
    ../../../../../source/: EVE_API.c EVE_HAL.c
    ../../../../../ports/eve_arch_stm32/: EVE_MCU_STM32.c
    ../../../../../include/: EVE.h EVE_config.h FT8xx.h HAL.h MCU.h
  group Drivers/CMSIS
    ../system/Src/: system_stm32f0xx.c
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c
  group Drivers/BSP/STM32F0308-Discovery
    ../../Drivers/BSP/STM32F0308-Discovery/: stm32f0308_discovery.c
software components: CMSIS:CORE 4.1.0
